## config/boards/shields/cygnus_dongle/Kconfig.shield
```kconfig
# SPDX-License-Identifier: MIT

config SHIELD_CYGNUS_DONGLE
    def_bool $(shields_list_contains,cygnus_dongle)
```
